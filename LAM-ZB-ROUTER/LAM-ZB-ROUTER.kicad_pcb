# Repository b4ck5p4c3/lambium

File README.md:

# Lambium

Monorepo for weird building control and automation devices we built in B4CKSP4CE.

## License

- Hardware designs are licensed under the CERN Open Hardware Licence Version 2 - Strongly Reciprocal (CERN-OHL-S-2.0).
- Software is licensed under the Mozilla Public License 2.0.

## KiCad design LAM-ZB-ROUTER/LAM-ZB-ROUTER.kicad_pcb

Parts:
C1: 100uF / 25V; CP_Radial_D6.3mm_P2.50mm
C4, C5: 10uF / 16V; C_0805_2012Metric
D1: PESD12VS1UB; D_SOD-523
D2: SS14; D_SMA
D3: RUN; LED_1206_3216Metric
F1: MF-NSMF050-2; Fuse_1206_3216Metric
H1, H2: MountingHole; MountingHole_3.2mm_M3_ISO7380
J1: PWR; PhoenixContact_MC_1,5_2-G-3.81_1x02_P3.81mm_Horizontal
J2: Conn_01x07_Pin; PinHeader_1x07_P2.54mm_Vertical
R1: 270R; R_0805_2012Metric
R2: 5K1; R_0805_2012Metric
SW1: FLASH; SW_Tactile_SPST_NO_Straight_CK_PTS636Sx25SMTRLFS
U1: CC2538; RF_Module_CC2538
U2: LT1117-3.3; SOT-223-3_TabPin2

Connections:
+3V3: C4.1, J2.2, SW1.2, U1.3 (VCC), U2.2 (VO)
+12V: C1.1, C5.1, F1.1, U2.3 (VI)
/RST: J2.1, U1.32 (RST)
/TCK: J2.4, U1.5 (TCK)
/TDI: J2.6, U1.7 (PB6/TDI)
/TDO: J2.5, U1.6 (PB7/TDO)
/TMS: J2.3, U1.4 (TMS)
GND: C1.2, C4.2, C5.2, D1.2 (A), J1.2 (GND), J2.7, R1.1, R2.2, U1.1 (GND), U1.2 (GND), U2.1 (GND)
unnamed: D1.1 (K), D2.2 (A), J1.1 (12V)
unnamed: D2.1 (K), F1.2
unnamed: D3.2 (A), U1.12 (PB1)
unnamed: D3.1 (K), R1.2
unnamed: R2.1, SW1.1, U1.29 (PA7)

Board: 2 copper layers, 44.0 x 69.2 mm, 16 parts (3 on the bottom side), 13 nets.

## KiCad design LAM-RPI-DMX/hardware/LAM-RPI-DMX/LAM-RPI-DMX.kicad_pcb

Parts:
BT1: CR2032; BatteryHolder_Keystone_1058_1x2032
C2: 0.1uF / 16V; C_0805_2012Metric
D1: PESD12VL2BT; SOT-23
H1: MountingHole; MountingHole_3.2mm_M3
J1: RPi GPIO Header; PinSocket_2x05_P2.54mm_Vertical
J2: PWR; PhoenixContact_MC_1,5_2-G-3.81_1x02_P3.81mm_Horizontal
J3: Conn_01x03_Socket; PhoenixContact_MC_1,5_3-G-3.81_1x03_P3.81mm_Horizontal
R1, R2: 10R; R_0805_2012Metric
R3: 0R; R_1206_3216Metric
TP2: 485A; TestPoint_Pad_D1.0mm
TP3: 485B; TestPoint_Pad_D1.0mm
U1: DS1307Z+; SOIC-8_3.9x4.9mm_P1.27mm
U2: ADM3485EARZ; SOIC-8_3.9x4.9mm_P1.27mm
U3: Mini360; Module_Mini360
Y1: 32.768K; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
+3V3: C2.2, J1.1 (3V3), U1.8 (VCC), U2.2 (~RE), U2.3 (DE), U2.8 (VCC)
+5V: J1.2 (5V), U3.4 (OUT+)
/SCL: J1.5 (I2C1_SCL), U1.6 (SCL)
/SDA: J1.3 (I2C1_SDA), U1.5 (SDA)
/TX: R3.2, U2.4 (DI)
GND: BT1.2 (-), C2.1, D1.3 (A), J1.9 (GND), J2.2 (GND), J3.3, U1.4 (GND), U2.5 (GND), U3.1 (GND), U3.3 (GND)
unnamed: BT1.1 (+), U1.3 (VBAT)
unnamed: J1.8 (UART_TX), R3.1
unnamed: J2.1 (12V), U3.2 (IN+)
unnamed: D1.1 (K), J3.1, R2.2, TP2.1
unnamed: D1.2 (K), J3.2, R1.2, TP3.1
unnamed: U1.1 (X1), Y1.2
unnamed: U1.2 (X2), Y1.1
unnamed: R2.1, U2.6 (A)
unnamed: R1.1, U2.7 (B)

Board: 2 copper layers, 55.0 x 58.0 mm, 16 parts (3 on the bottom side), 15 nets.

## KiCad design LAM-4I4O/hardware/LAM-4I4O-REVC/LAM-4I4O-REVC.kicad_pcb

File LAM-4I4O/README.md:

# LAM-4I4O

Endpoint-style device with four inputs and four outputs.

## Capabilities

- **Inputs:** Four non-isolated discrete inputs (0 to 12V).
- **Outputs:** Four non-isolated outputs (12V, 1A max).
- **Power:** 7-12V DC input. Logic is fused at 0.75A, IO is not fused.
- **Connectivity:** Single 8P8C connector for Modbus RTU over RS-485.

## Modbus

- **Address:** individual for each device, set in firmware.
- **Port configuration:** 115200, 8N1

### Coils Registers

- **0x0001:** Output 1 value (Read, Write)
- **0x0002:** Output 2 value (Read, Write)
- **0x0003:** Output 3 value (Read, Write)
- **0x0004:** Output 4 value (Read, Write)

### Discrete Inputs Registers

- **0x0001** Current Input 1 value (Read)
- **0x0002** Current Input 2 value (Read)
- **0x0003** Current Input 3 value (Read)
- **0x0004** Current Input 4 value (Read)

LAM-4I4O also supports latched inputs.
They hold the positive edge of the input signal until it's read.
It's useful for detecting short pulses, like button presses.

- **0x1001** Latched Input 1 value (Read)
- **0x1002** Latched Input 2 value (Read)
- **0x1003** Latched Input 3 value (Read)
- **0x1004** Latched Input 4 value (Read)

Parts:
C1, C2, C3: 0.1uF / 16V; C_0805_2012Metric
C4, C5: 10uF / 16V; C_0805_2012Metric
C6: 470uF / 25V; CP_Elec_6.3x5.9
D1: PESD15VL2BT; SOT-23; Mouser Part Number 771-PESD15VS2UT-T/R
D2: SS14; D_SMA
D3: PESD12VS1UB; D_SOD-523
D4, D5, D6: LED; LED_1206_3216Metric_ReverseMount_Hole1.8x2.4mm
F1: MF-SM075-2; FUSE-SMD_L7.4-W5.4
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_DIN965_Pad_TopOnly
J1, J2, J3: MC1,5 2G-3.81; PhoenixContact_MCV_1,5_2-G-3.81_1x02_P3.81mm_Vertical
R1, R2: 10R; R_0805_2012Metric
R3, R4, R5: 200R; R_0805_2012Metric
TP1: SWIO; TestPoint_Pad_D1.5mm
TP2: 485B; TestPoint_Pad_D1.0mm
TP3: 485A; TestPoint_Pad_D1.0mm
TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13: TestPoint; TestPoint_Pad_D1.0mm
U1: CH32V003AxMx; SOP-16_3.9x9.9mm_P1.27mm
U2: SN75176BDR; SOIC-8_3.9x4.9mm_P1.27mm
U3: LT1117-5.0; SOT-223-3_TabPin2

Connections:
+5V: C1.2, C2.2, C4.1, R4.1, U1.15 (VDD), U2.8 (VCC), U3.2 (VO); also elsewhere on the board
+12V: C5.1, C6.1, F1.2, U3.3 (VI); also elsewhere on the board
/DBG_LED: R5.1, U1.16 (PC0)
/IN1: TP6.1, U1.4 (PC4); also elsewhere on the board
/IN2: TP7.1, U1.3 (PC3); also elsewhere on the board
/IN3: TP8.1, U1.2 (PC2); also elsewhere on the board
/IN4: TP9.1, U1.1 (PC1); also elsewhere on the board
/OUT1: TP10.1, U1.5 (PC6); also elsewhere on the board
/OUT2: TP11.1, U1.6 (PC7); also elsewhere on the board
/OUT3: TP12.1, U1.8 (PD4); also elsewhere on the board
/OUT4: TP13.1, U1.13 (PA2); also elsewhere on the board
/RX: U1.9 (PD5), U2.1 (R)
/TX: U1.10 (PD6), U2.4 (D)
/TXEN: R3.1, U1.12 (PA1), U2.2 (~RE), U2.3 (DE)
GND: C1.1, C2.1, C3.1, C4.2, C5.2, C6.2, D1.3 (GND), D3.2 (A), D4.1 (K), D5.1 (K), D6.1 (K), H1.1, H2.1, H3.1, H4.1, J3.2, U1.14 (VSS), U2.5 (GND), U3.1 (GND); also elsewhere on the board
unnamed: D1.1 (IN1), J1.1, J2.1, R2.2, TP2.1
unnamed: D1.2 (IN2), J1.2, J2.2, R1.2, TP3.1
unnamed: D2.2 (A), D3.1 (K), J3.1
unnamed: D2.1 (K), F1.1
unnamed: D4.2 (A), R3.2
unnamed: D5.2 (A), R4.2
unnamed: D6.2 (A), R5.2
unnamed: TP1.1, U1.7 (PD1)
unnamed: C3.2, U1.11 (PD7)
unnamed: R1.1, U2.6 (A)
unnamed: R2.1, U2.7 (B)

Parts:
D7, D8, D9, D10: BZV55C5V1; D_MiniMELF
D11, D12, D13, D14: LL4448; D_MiniMELF
D15, D16: PESD12VS2UT; SOT-23; Mouser Part Number 771-PESD15VS2UT-T/R
F2, F3, F4, F5: MF-NSMF050-2; Fuse_1206_3216Metric; LCSC Part C75464
J4: PLS; PinHeader_1x03_P2.54mm_Vertical
J5, J6, J7, J8, J9, J10, J11, J12: MC 1,5/2G-3,81; PhoenixContact_MC_1,5_2-G-3.81_1x02_P3.81mm_Horizontal
R6, R7, R8, R9: 1K; R_0805_2012Metric
U4: ULN2003; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+5V: J4.1; also elsewhere on the board
+12V: J4.3; also elsewhere on the board
/IN1: D7.1 (K), R6.1; also elsewhere on the board
/IN2: D8.1 (K), R7.1; also elsewhere on the board
/IN3: D10.1 (K), R9.1; also elsewhere on the board
/IN4: D9.1 (K), R8.1; also elsewhere on the board
/IO/IO_VCC: J4.2, J5.1, J6.1, J7.1, J8.1, J9.2, J10.2, J11.2, J12.2, U4.9 (COM)
/OUT1: U4.4 (I4); also elsewhere on the board
/OUT2: U4.3 (I3); also elsewhere on the board
/OUT3: U4.2 (I2); also elsewhere on the board
/OUT4: U4.1 (I1); also elsewhere on the board
GND: D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), D15.3 (GND), D16.3 (GND), U4.8 (GND); also elsewhere on the board
unnamed: D11.2 (A), D15.2 (IN2), J5.2
unnamed: D11.1 (K), R6.2
unnamed: D12.2 (A), D15.1 (IN1), J7.2
unnamed: D12.1 (K), R7.2
unnamed: D13.2 (A), D16.1 (IN1), J6.2
unnamed: D13.1 (K), R8.2
unnamed: D14.2 (A), D16.2 (IN2), J8.2
unnamed: D14.1 (K), R9.2
unnamed: F2.1, J9.1
unnamed: F3.1, J10.1
unnamed: F4.1, J11.1
unnamed: F5.1, J12.1
unnamed: F2.2, U4.16 (O1)
unnamed: F3.2, U4.15 (O2)
unnamed: F4.2, U4.14 (O3)
unnamed: F5.2, U4.13 (O4)

Notes on the sheet:
– Input operating range: 0V~12V, Vhi = 5V – LL4448 instead of Schotky to optimise BOM – PESD12VS2UT Vbreakdown = 15V – CH32V003DS0 Vin(max) = Vdd + 0.3 = 5.3V

Board: 2 copper layers, 65.0 x 80.0 mm, 67 parts (12 on the bottom side), 43 nets.
