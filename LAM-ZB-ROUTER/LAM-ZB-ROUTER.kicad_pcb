# Repository b4ck5p4c3/lambium (continued)

## KiCad design LAM-4I4O/hardware/LAM-4I4O-REVB/LAM-MEW-G3.kicad_pcb

Parts:
C1, C2, C3: 0.1uF / 16V; C_0805_2012Metric
C4, C5: 10uF / 16V; C_0805_2012Metric
C6: 470uF / 25V; CP_Elec_6.3x5.9
D1: PESD15VL2BT; SOT-23; Mouser Part Number 771-PESD15VS2UT-T/R
D2: SS14; D_SMA
D3: PESD12VS1UB; D_SOD-523
D4, D5, D6: LED; LED_1206_3216Metric_ReverseMount_Hole1.8x2.4mm
F1: MF-SM075-2; FUSE-SMD_L7.4-W5.4
H1: MountingHole_Pad; MountingHole_3.2mm_M3_DIN965_Pad_TopOnly
J1, J2, J3: MC1,5 2G-3.81; PhoenixContact_MC_1,5_2-G-3.81_1x02_P3.81mm_Horizontal
R1, R2: 10R; R_0805_2012Metric
R3, R4, R5: 200R; R_0805_2012Metric
TP1: SWIO; TestPoint_Pad_D2.5mm
TP2: 485B; TestPoint_Pad_D2.5mm
TP3: 485A; TestPoint_Pad_D2.5mm
TP4: 5V; TestPoint_Pad_D2.5mm
TP5: 12V; TestPoint_Pad_D2.5mm
U1: CH32V003AxMx; SOP-16_3.9x9.9mm_P1.27mm
U2: SN75176BDR; SOIC-8_3.9x4.9mm_P1.27mm
U3: LT1117-5.0; SOT-223

Connections:
+5V: C1.2, C2.2, C4.1, R4.1, TP4.1, U1.15 (VDD), U2.8 (VCC), U3.2 (VO); also elsewhere on the board
+12V: C5.1, C6.1, F1.1, TP5.1, U3.3 (VI); also elsewhere on the board
/DBG_LED: R5.1, U1.13 (PA2)
/IN1: U1.5 (PC6); also elsewhere on the board
/IN2: U1.12 (PA1); also elsewhere on the board
/IN3: U1.6 (PC7); also elsewhere on the board
/IN4: U1.8 (PD4); also elsewhere on the board
/OUT1: U1.4 (PC4); also elsewhere on the board
/OUT2: U1.3 (PC3); also elsewhere on the board
/OUT3: U1.2 (PC2); also elsewhere on the board
/OUT4: U1.1 (PC1); also elsewhere on the board
/RX: U1.9 (PD5), U2.1 (R)
/TX: U1.10 (PD6), U2.4 (D)
/TXEN: R3.1, U1.16 (PC0), U2.2 (~RE), U2.3 (DE)
GND: C1.1, C2.1, C3.1, C4.2, C5.2, C6.2, D1.3 (GND), D3.2 (A), D4.1 (K), D5.1 (K), D6.1 (K), H1.1, J3.2, U1.14 (VSS), U2.5 (GND), U3.1 (GND); also elsewhere on the board
unnamed: D1.1 (IN1), J1.1, J2.1, R2.2, TP2.1
unnamed: D1.2 (IN2), J1.2, J2.2, R1.2, TP3.1
unnamed: D2.2 (A), D3.1 (K), J3.1
unnamed: D2.1 (K), F1.2
unnamed: D4.2 (A), R3.2
unnamed: D5.2 (A), R4.2
unnamed: D6.2 (A), R5.2
unnamed: TP1.1, U1.7 (PD1)
unnamed: C3.2, U1.11 (PD7)
unnamed: R1.1, U2.6 (A)
unnamed: R2.1, U2.7 (B)

Parts:
D7, D8, D9, D10: BZV55C5V1; D_MiniMELF
D11, D12, D13, D14: LL4448; D_MiniMELF
D15, D16: PESD12VS2UT; SOT-23; Mouser Part Number 771-PESD15VS2UT-T/R
F2, F3, F4, F5: MF-NSMF050-2; Fuse_1206_3216Metric; LCSC Part C75464
J4: PLS; PinHeader_1x03_P2.54mm_Vertical
J5, J6, J7, J8, J9, J10, J11, J12: MC 1,5/2G-3,81; PhoenixContact_MC_1,5_2-G-3.81_1x02_P3.81mm_Horizontal
R6, R7, R8, R9: 1K; R_0805_2012Metric
R10, R11, R12: 0R; R_1206_3216Metric
U4: ULN2003; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+5V: J4.1; also elsewhere on the board
+12V: J4.3; also elsewhere on the board
/IN1: D7.1 (K), R6.1; also elsewhere on the board
/IN2: D8.1 (K), R7.1; also elsewhere on the board
/IN3: D9.1 (K), R8.1; also elsewhere on the board
/IN4: D10.1 (K), R9.1; also elsewhere on the board
/IO/IO_VCC: J4.2, J5.1, J6.1, J7.1, J8.1, J9.2, J10.2, J11.2, J12.2, U4.9 (COM)
/OUT1: U4.1 (I1); also elsewhere on the board
/OUT2: U4.2 (I2); also elsewhere on the board
/OUT3: U4.3 (I3); also elsewhere on the board
/OUT4: U4.4 (I4); also elsewhere on the board
GND: D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), D15.3 (GND), D16.3 (GND), R10.1, R10.2, R11.1, R11.2, R12.1, R12.2, U4.8 (GND); also elsewhere on the board
unnamed: D11.2 (A), D15.1 (IN1), J5.2
unnamed: D11.1 (K), R6.2
unnamed: D12.2 (A), D15.2 (IN2), J7.2
unnamed: D12.1 (K), R7.2
unnamed: D13.2 (A), D16.2 (IN2), J6.2
unnamed: D13.1 (K), R8.2
unnamed: D14.2 (A), D16.1 (IN1), J8.2
unnamed: D14.1 (K), R9.2
unnamed: F2.2, J9.1
unnamed: F3.2, J10.1
unnamed: F4.2, J11.1
unnamed: F5.2, J12.1
unnamed: F2.1, U4.16 (O1)
unnamed: F3.1, U4.15 (O2)
unnamed: F4.1, U4.14 (O3)
unnamed: F5.1, U4.13 (O4)

Notes on the sheet:
– Input operating range: 0V~12V, Vhi = 5V – LL4448 instead of Schotky to optimise BOM – PESD12VS2UT Vbreakdown = 15V – CH32V003DS0 Vin(max) = Vdd + 0.3 = 5.3V

Board: 2 copper layers, 53.0 x 80.0 mm, 61 parts (12 on the bottom side), 43 nets.

## KiCad design LAM-4I4O/hardware/lam-4i4o.kicad_pcb

Parts:
C1, C2: 10nF; C_1206_3216Metric
C3, C4: 100nF; C_1206_3216Metric
C5: 100pF; C_1206_3216Metric
D1, D3, D4, D5: LL4448; D_MiniMELF
D2: PESD15VL2BT; SOT-23; Mouser Part Number 771-PESD15VS2UT-T/R
D6, D7: PESD15VS2UT; SOT-23; Mouser Part Number 771-PESD15VS2UT-T/R
F1: MF-SM075-2; FUSE-SMD_L7.4-W5.4
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
J1, J2, J3, J4, J6, J7, J8, J9: MC 1,5/2G-3,81; PhoenixContact_MC_1,5_2-G-3.81_1x02_P3.81mm_Horizontal
J5: 8P8C; Connfly_DS1134
J10: TC2030-NL; Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical
Q1, Q2, Q3, Q4: AO3402A; SOT-23
R1, R6, R8, R10: 220R; R_1206_3216Metric
R2, R3, R4: 4K7; R_1206_3216Metric
R5, R7, R9, R11: 10K; R_1206_3216Metric
R12, R13, R14, R15: 470R; R_1206_3216Metric
Rterm1: 100R; R_1206_3216Metric
U1: AMS1117-5.0; SOT-223-3_TabPin2
U2: SN75176BDR; SOIC-8_3.9x4.9mm_P1.27mm
U3: CH32V003AxMx; SOP-16_3.9x9.9mm_P1.27mm

Connections:
+5V: C2.1, C3.2, C4.2, R2.1, R3.1, R4.1, U1.2 (VO), U2.8 (VCC), U3.15 (VDD)
+12V: F1.1, J5.6, J6.1, J7.1, J8.1, J9.1
/485_N: D2.1 (IN1), J5.5, Rterm1.2, U2.6 (A)
/485_P: D2.2 (IN2), J5.4, Rterm1.1, U2.7 (B)
GND: C1.2, C2.2, C3.1, C4.1, C5.2, D1.2 (A), D2.3 (GND), D3.2 (A), D4.2 (A), D5.2 (A), D6.3 (GND), D7.3 (GND), J1.2, J2.2, J3.2, J4.2, J5.7, J5.8, J10.5 (GND), Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), R5.2, R7.2, R9.2, R11.2, U1.1 (GND), U2.5 (GND), U3.14 (VSS)
IN1: D6.2 (IN2), R12.2, U3.6 (PC7)
IN2: D6.1 (IN1), R13.2, U3.8 (PD4)
IN3: D7.2 (IN2), R14.2, U3.4 (PC4)
IN4: D7.1 (IN1), R15.2, U3.5 (PC6)
unnamed: D1.1 (K), J1.1, Q1.3 (D)
unnamed: D3.1 (K), J2.1, Q2.3 (D)
unnamed: D4.1 (K), J3.1, Q3.3 (D)
unnamed: D5.1 (K), J4.1, Q4.3 (D)
unnamed: J6.2, R12.1
unnamed: J7.2, R13.1
unnamed: J8.2, R14.1
unnamed: J9.2, R15.1
unnamed: Q1.1 (G), R1.1, R5.1
unnamed: Q2.1 (G), R6.1, R7.1
unnamed: Q3.1 (G), R8.1, R9.1
unnamed: Q4.1 (G), R10.1, R11.1
unnamed: C1.1, F1.2, U1.3 (VI)
unnamed: C5.1, U3.11 (PD7)
OUT1: R1.2, U3.3 (PC3)
OUT2: R6.2, U3.2 (PC2)
OUT3: R8.2, U3.1 (PC1)
OUT4: R10.2, U3.16 (PC0)
RX: R4.2, U2.1 (R), U3.10 (PD6)
STATUS: U3.13 (PA2)
SWD: J10.2 (SWDIO), U3.7 (PD1)
TX: R3.2, U2.4 (D), U3.9 (PD5)
TXEN: R2.2, U2.2 (~RE), U2.3 (DE), U3.12 (PA1)

Notes on the sheet:
C4 MUST be installed as close to MCU as possible
Pin 3 CAN be connected to 12V, but it's not neccessary.
Rterm depends on a cable type: 1. UTP Cat 5/5e = 100R Rterm must be set only on a leading and trailing devices on bus leafs.

Board: 2 copper layers, 83.0 x 62.0 mm, 50 parts (9 on the bottom side), 31 nets.

## Code that names these connections

File LAM-4I4O/firmware/src/mcu_config.h:

#ifndef MCU_CONFIG_H_
#define MCU_CONFIG_H_

#include <ch32v00x.h>

#define MODBUS_UART USART1
#define MODBUS_SPEED 115200
#define MODBUS_SLAVE_ID 230

#define TX_PORT GPIOD
#define TX_PIN GPIO_Pin_6

#define RX_PORT GPIOD
#define RX_PIN GPIO_Pin_5

#define DIR_PORT GPIOA
#define DIR_PIN GPIO_Pin_1

#define DBG_LED_PORT GPIOC
#define DBG_LED_PIN GPIO_Pin_0

#define IN1_PORT GPIOC
#define IN1_PIN GPIO_Pin_4
#define IN1_PORT_SOURCE GPIO_PortSourceGPIOC
#define IN1_PIN_SOURCE GPIO_PinSource4
#define IN1_EXTI_LINE EXTI_Line4

#define IN2_PORT GPIOC
#define IN2_PIN GPIO_Pin_3
#define IN2_PORT_SOURCE GPIO_PortSourceGPIOC
#define IN2_PIN_SOURCE GPIO_PinSource3
#define IN2_EXTI_LINE EXTI_Line3

#define IN3_PORT GPIOC
#define IN3_PIN GPIO_Pin_2
#define IN3_PORT_SOURCE GPIO_PortSourceGPIOC
#define IN3_PIN_SOURCE GPIO_PinSource2
#define IN3_EXTI_LINE EXTI_Line2

#define IN4_PORT GPIOC
#define IN4_PIN GPIO_Pin_1
#define IN4_PORT_SOURCE GPIO_PortSourceGPIOC
#define IN4_PIN_SOURCE GPIO_PinSource1
#define IN4_EXTI_LINE EXTI_Line1

#define OUT1_PORT GPIOC
#define OUT1_PIN GPIO_Pin_6

#define OUT2_PORT GPIOC
#define OUT2_PIN GPIO_Pin_7

#define OUT3_PORT GPIOD
#define OUT3_PIN GPIO_Pin_4

#define OUT4_PORT GPIOA
#define OUT4_PIN GPIO_Pin_2

#endif  // MCU_CONFIG_H

## Commit log

2024-11-10 LAM-4I4O: drafts
2025-04-03 feat(LAM-4I4O): add Rev B & C
2025-04-04 fix(LAM-4I4O): RS-485 connector spacing
2025-04-04 fix(LAM-4I4O): increase trace length to 0.5mm, fix missing ground trace for single-layer manufacturing
2025-04-06 feat(LAM-4I4O): add firmware stub
2025-04-06 add firmware
2025-04-14 fix(LAM-4I4O): incorrect PESD12VL2BT value in RS-485
2025-06-08 LAM-RPI-DMX: first draft
2025-06-12 Library: update
2025-06-12 LAM-RPI-DMX: Revision A
2025-06-12 LAM-ZB-ROUTER: Revision A
2025-06-15 LAM-ZB-ROUTER: Rev B
2026-05-02 fix: 4i40 move to new library and fix minor bugs
